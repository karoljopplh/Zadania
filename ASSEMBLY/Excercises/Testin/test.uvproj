# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: better_blinker.a51 different_blinker.a51 one_second_blinker.a51
